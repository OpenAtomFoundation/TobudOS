<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NUCLEO_STM32F401RE.ewp</path>
  </project>
  <batchBuild />
</workspace>
