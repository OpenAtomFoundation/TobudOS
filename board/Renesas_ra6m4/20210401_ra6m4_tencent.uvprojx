# Keil uVision project 20210401_ra6m4_tencent.uvprojx, settings and files
target TencentOS_Tiny (6140000::V6.14::ARMCLANG)
  device: R7FA6M4AF3CFB Renesas
  pack: Renesas.RA_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: 20210401_ra6m4_tencent
  AfterMake: cmd /c ""C:\Renesas\RA\sc_v2021-01_fsp_v2.4.0\eclipse\rasc.exe" --gensecurebundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: ..\..\arch\arm\arm-v8m\common\include;..\..\arch\arm\arm-v8m\cortex-m33\armcc;..\..\kernel\core\include;..\..\kernel\hal\include;..\..\osal\cmsis_os;.\TOS-CONFIG
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c Driver_Common.h uart_stdout.c uart_stdout.h
  group tos/arch
    ../../arch/arm/arm-v8m/common/: tos_cpu.c
    ../../arch/arm/arm-v8m/cortex-m33/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../osal/cmsis_os/: cmsis_os.c
  group examples
    ../../examples/hello_world/: hello_world.c
software components: Flex Software:RA Configuration 1.0.0
