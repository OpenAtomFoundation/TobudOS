# IAR project TencentOS_tiny.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m32 ATmega32
  ICCAVR.newCCIncludePaths: ..\..\..\..\arch\AVR\common\include; ..\..\..\..\arch\avr\ATMega32\iccavr; ..\..\..\..\kernel\core\include; ..\..\BSP\include; ..\..\TOS-CONFIG; ..\..\LIB\inc
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm32.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group ARCH
    ../../../../arch/avr/ATMega32/iccavr/: port.h port_c.c port_config.h port_s.asm
    ../../../../arch/avr/common/: tos_cpu.c tos_fault.c
  group BSP/INC
    ../../BSP/include/: tim.h uart.h
  group BSP/SRC
    ../../BSP/src/: hal_uart.c tim.c uart.c
  group KERNEL
    ../../../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group LIB/INC
    ../../LIB/inc/: stdint.h
  group TOS_CONFIG
    ../../TOS-CONFIG/: tos_config.h
  group USER
    ../../USER/: main.c
