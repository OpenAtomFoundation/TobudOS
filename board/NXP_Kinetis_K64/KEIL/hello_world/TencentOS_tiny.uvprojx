# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny_K64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TencentOS_tiny
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK64F12 RAVEN DEBUG
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\nxp\CH-K-Lib\drivers\K\inc;..\..\..\..\platform\vendor_bsp\nxp\CH-K-Lib\startup\DeviceSupport;..\..\..\..\platform\vendor_bsp\nxp\CH-K-Lib\startup\CoreSupport;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ./: startup_MK64F12.s
    ../../../../platform/vendor_bsp/nxp/CH-K-Lib/startup/DeviceSupport/: system_MK64F12.c
  group drivers
    ../../../../platform/vendor_bsp/nxp/CH-K-Lib/drivers/K/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c i2s.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group user
    ../../BSP/Src/: main.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
