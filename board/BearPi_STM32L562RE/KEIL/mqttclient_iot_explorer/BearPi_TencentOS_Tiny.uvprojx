# Keil uVision project BearPi_TencentOS_Tiny.uvprojx, settings and files
target BearPi_TencentOS_Tiny (6140000::V6.14::ARMCLANG)
  device: STM32L562RETx STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: BearPi_TencentOS_Tiny
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L562xx
  c include: ..\..\BSP\Inc;..\..\BSP\Hardware\LCD_ST7789;..\..\..\..\platform\vendor_bsp\st\STM32L5xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L5xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L5xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v8m\common\include;..\..\..\..\arch\arm\arm-v8m\cortex-m33\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\hal\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\..\..\..\net\at\include;..\..\..\..\net\sal_module_wrapper;..\..\..\..\devices\esp8266;..\..\..\..\components\connectivity\mqttclient\common;..\..\..\..\components\connectivity\mqttclient\common\log;..\..\..\..\components\connectivity\mqttclient\mqtt;..\..\..\..\components\connectivity\mqttclient\mqttclient;..\..\..\..\components\connectivity\mqttclient\network;..\..\..\..\components\connectivity\mqttclient\platform\TencentOS-tiny;..\..\..\..\components\utils\JSON\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32l562xx.s
  group Application/User
    ../../BSP/Src/: adc.c dac.c gpio.c i2c.c main.c octospi.c sdmmc.c spi.c stm32l5xx_it_module.c stm32l5xx_hal_msp.c usart.c mcu_init.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dac.c stm32l5xx_hal_dac_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_ll_sdmmc.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l5xx.c
  group HardWare
    ../../BSP/Hardware/LCD_ST7789/: lcd_spi2_drv.c
  group tos/arch
    ../../../../arch/arm/arm-v8m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v8m/cortex-m33/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group tos_config
    ../../TOS_CONFIG/: tos_config.h
  group example
    ./demo/: mqttclient_iot_explorer.c
  group at
    ../../../../net/at/src/: tos_at.c
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group cjson
    ../../../../components/utils/JSON/src/: cJSON.c
  group devices
    ../../../../devices/esp8266/: esp8266.c
  group hal
    ../../../../platform/hal/st/stm32l5xx/src/: tos_hal_uart.c
  group mqttclient
    ../../../../components/connectivity/mqttclient/mqttclient/: mqttclient.c
  group mqttclient/mqtt
    ../../../../components/connectivity/mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient/salof
    ../../../../components/connectivity/mqttclient/common/log/arch/tencentos-tiny/: arch.c
    ../../../../components/connectivity/mqttclient/common/log/: fifo.c format.c salof.c salof_config.h
  group mqttclient/common
    ../../../../components/connectivity/mqttclient/common/: mqtt_list.c random.c mqtt_error.h mqtt_log.h
  group mqttclient/network
    ../../../../components/connectivity/mqttclient/network/: nettype_tcp.c nettype_tls.c network.c
  group mqttclient/platform
    ../../../../components/connectivity/mqttclient/platform/TencentOS-tiny/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group mqttclient/config
    ../../TOS_CONFIG/: mqtt_config.h
software components: CMSIS:CORE 4.3.0
