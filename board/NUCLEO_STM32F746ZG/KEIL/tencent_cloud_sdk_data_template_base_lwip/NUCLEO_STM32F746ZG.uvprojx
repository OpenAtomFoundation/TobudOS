# Keil uVision project NUCLEO_STM32F746ZG.uvprojx, settings and files
target NUCLEO_STM32F746ZG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: NUCLEO_STM32F746ZG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_HAL_DRIVER,STM32F746xx,MBEDTLS_CONFIG_FILE=<qcloud/dtls_psk_config.h>,
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F7xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F7xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m7\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\..\..\..\net\lwip\3rdparty\src\include;..\..\..\..\net\lwip\port\include;..\..\..\..\components\connectivity\TencentCloud_SDK\source\include;..\..\..\..\components\security\mbedtls\3rdparty\include;..\..\..\..\components\security\mbedtls\wrapper\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32f7xx_hal_msp.c stm32f7xx_it.c usart.c usb_otg.c bsp_eth.c lwip.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_ll_usb.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32f7xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m7/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_event.c tos_fifo.c tos_global.c tos_mmblk.c tos_mmheap.c tos_msg.c tos_mutex.c tos_pend.c tos_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group lwip
    ../../../../net/lwip/3rdparty/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../net/lwip/3rdparty/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../net/lwip/3rdparty/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../net/lwip/3rdparty/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group lwip/port
    ../../../../net/lwip/port/src/: ethernetif.c sys_arch.c
  group lwip/config
    ../../TOS_CONFIG/: lwipopts.h
  group example
    ../../../../examples/tencent_cloud_sdk_data_template/: light_data_template_sample.c tencent_cloud_sdk_explorer.c
  group mbedtls
    ../../../../components/security/mbedtls/3rdparty/src/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../components/security/mbedtls/wrapper/src/: entropy_hardware_alt.c net_sockets_alt.c timing_alt.c
  group qcloud
    ../../../../components/connectivity/TencentCloud_SDK/source/src/: qcloud_device.c qcloud_log.c qcloud_network.c qcloud_tls.c
  group qcloud/mqtt
    ../../../../components/connectivity/TencentCloud_SDK/source/src/mqtt/: qcloud_mqtt_client.c qcloud_mqtt_common.c qcloud_mqtt_connect.c qcloud_mqtt_glue.c qcloud_mqtt_publish.c qcloud_mqtt_subscribe.c qcloud_mqtt_unsubscribe.c qcloud_mqtt_yield.c
  group qcloud/port
    ../../../../components/connectivity/TencentCloud_SDK/source/src/port/TencentOS_tiny/: osal_dtls.c osal_os.c osal_tcp_socket.c osal_timer.c osal_tls.c osal_udp_socket.c
  group qcloud/utils
    ../../../../components/connectivity/TencentCloud_SDK/source/src/utils/: qcloud_aes.c qcloud_base64.c qcloud_hmac.c qcloud_httpc.c qcloud_json_parser.c qcloud_json_token.c qcloud_md5.c qcloud_sha1.c qcloud_string_utils.c
  group qcloud/shadow
    ../../../../components/connectivity/TencentCloud_SDK/source/src/shadow/: qcloud_shadow_client.c qcloud_shadow_glue.c qcloud_shadow_json.c
software components: CMSIS:CORE 4.3.0
