# Keil uVision project CSTX_STM32F103RE_DTU.uvprojx, settings and files
target CSTX_STM32F103RE_DTU (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CSTX_STM32F103RE_DTU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F1xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m3\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\..\..\..\net\at\include;..\..\..\..\net\sal_module_wrapper;..\..\..\..\devices\ec200s;..\..\..\..\kernel\hal\include;..\..\..\..\components\connectivity\mqttclient\common;..\..\..\..\components\connectivity\mqttclient\common\log;..\..\..\..\components\connectivity\mqttclient\mqtt;..\..\..\..\components\connectivity\mqttclient\mqttclient;..\..\..\..\components\connectivity\mqttclient\network;..\..\..\..\components\connectivity\mqttclient\platform\TencentOS-tiny;..\..\..\..\components\utils\JSON\include;..\..\BSP\Hardware\DS18B20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32f1xx_hal_msp.c usart.c stm32f1xx_it_module.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32f1xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/cortex-m3/armcc/: port_c.c port_s.S
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group tos/kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_stopwatch.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group tos/config
    ../../TOS_CONFIG/: tos_config.h
  group examples
    ./demo/: mqttclient_iot_explorer_ds18b20_relay.c
  group at
    ../../../../net/at/src/: tos_at.c
    ../../../../platform/hal/st/stm32f1xx/src/: tos_hal_uart.c
  group net
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group devices
    ../../../../devices/ec200s/: ec200s.c
  group mqttclient
    ../../../../components/connectivity/mqttclient/mqttclient/: mqttclient.c
  group mqttclient/mqtt
    ../../../../components/connectivity/mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient/salof
    ../../../../components/connectivity/mqttclient/common/log/arch/tencentos-tiny/: arch.c
    ../../../../components/connectivity/mqttclient/common/log/: fifo.c format.c salof.c salof_config.h
  group mqttclient/common
    ../../../../components/connectivity/mqttclient/common/: random.c mqtt_list.c mqtt_log.h mqtt_error.h
  group mqttclient/network
    ../../../../components/connectivity/mqttclient/network/: network.c nettype_tcp.c nettype_tls.c
  group mqttclient/platform
    ../../../../components/connectivity/mqttclient/platform/TencentOS-tiny/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group mqttclient/config
    ../../TOS_CONFIG/: mqtt_config.h
  group cjson
    ../../../../components/utils/JSON/src/: cJSON.c
  group Hardware
    ../../BSP/Hardware/DS18B20/core_delay/: core_delay.c
    ../../BSP/Hardware/DS18B20/: ds18b20.c
software components: CMSIS:CORE 5.4.0
