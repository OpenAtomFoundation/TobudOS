# Keil uVision project TencentOS_Tiny.uvprojx, settings and files
target TencentOS_Tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G457MEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.0.4.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TencentOS_Tiny +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\nationz\Nationstech.N32G45x_Library.0.4.0\CMSIS\core;..\..\..\..\platform\vendor_bsp\nationz\Nationstech.N32G45x_Library.0.4.0\CMSIS\device;..\..\..\..\platform\vendor_bsp\nationz\Nationstech.N32G45x_Library.0.4.0\n32g45x_std_periph_driver\inc;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\hal\include;..\..\TOS_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../platform/vendor_bsp/nationz/Nationstech.N32G45x_Library.0.4.0/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../../../platform/vendor_bsp/nationz/Nationstech.N32G45x_Library.0.4.0/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../../../platform/vendor_bsp/nationz/Nationstech.N32G45x_Library.0.4.0/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_usart.c n32g45x_wwdg.c n32g45x_xfmc.c
  group USER
    ../../BSP/Src/: main.c n32g45x_it.c log.c mcu_init.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
