# Keil uVision project BearPi_STM32L31RC.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,WITH_TOS_NET_ADAPTER,USE_ESP8266,USE_MICROPYTHON
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\kernel\core\include;..\..\TOS-CONFIG;..\..\..\..\platform\arch\arm\cortex-m4\keil;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\..\net\at\include;..\..\..\..\kernel\hal\include;..\..\..\..\devices\esp8266;..\..\..\..\net\at\include;..\..\..\..\net\sal_module_wrapper;..\..\..\..\net\socket_wrapper\include;..\..\BSP\Hardware\LCD_ST7789;..\..\BSP\Hardware\BH1750;..\..\BSP\Hardware\W25QXX-QSPI;..\..\..\..\examples\micropython_demo;..\..\..\..\components\fs\vfs\include;..\..\..\..\components\fs\fatfs\wrapper\include;..\..\..\..\components\fs\fatfs\3rdparty;..\..\..\..\components\language\micropython;..\..\..\..\components\language\micropython\port;..\..\..\..\components\language\micropython\port\modules;..\micropython_extra_demo;.\board;.\board\hal
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32l4xx_hal_msp.c stm32l4xx_it_mpy.c usart.c adc.c i2c.c spi.c sdmmc.c quadspi.c
  group examples
    ../../../../examples/micropython_demo/: micropython_demo.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_qspi.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l4xx.c
  group Hardware
    ../../BSP/Hardware/BH1750/: BH1750.c
    ../../BSP/Hardware/LCD_ST7789/: lcd_spi2_drv.c
    ../../BSP/Hardware/W25QXX-QSPI/: w25qxx.c
  group kernel
    ../../../../kernel/core/: tos_mmblk.c tos_mmheap.c tos_mutex.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_event.c tos_global.c tos_pend.c tos_robin.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_stopwatch.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_s.S port_c.c
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group config
    ../../TOS-CONFIG/: tos_config.h
  group hal
    ../../../../platform/hal/st/stm32l4xx/src/: tos_hal_uart.c tos_hal_sd.c
    ../micropython_basic_demo/board/hal/: mp_tos_hal_pin.c mp_tos_hal_spi.c mp_tos_hal_uart.c
  group net
    ../../../../net/at/src/: tos_at.c
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
    ../../../../net/socket_wrapper/: tos_at_socket.c tos_at_socket_lib.c tos_at_socket_prv.c
  group devices
    ../../../../devices/esp8266/: esp8266.c
  group vfs
    ../../../../components/fs/vfs/: tos_vfs.c tos_vfs_device.c tos_vfs_file.c tos_vfs_fs.c tos_vfs_inode.c
  group fatfs
    ../../../../components/fs/fatfs/wrapper/: tos_diskio.c tos_fatfs_drv.c tos_fatfs_vfs.c tos_ff.c tos_ffsystem.c tos_ffunicode.c
  group micropython/py
    ../../../../components/language/micropython/py/: argcheck.c asmarm.c asmbase.c asmthumb.c asmx64.c asmx86.c asmxtensa.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitinlinextensa.c emitnarm.c emitnative.c emitnthumb.c emitnx64.c emitnx86.c emitnxtensa.c emitnxtensawin.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpz.c nativeglue.c nlr.c nlraarch64.c nlrpowerpc.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c pairheap.c parse.c parsenum.c parsenumbase.c persistentcode.c profile.c pystack.c qstr.c reader.c repl.c ringbuf.c runtime.c runtime_utils.c scheduler.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c
  group micropython/shared
    ../../../../components/language/micropython/shared/readline/: readline.c
    ../../../../components/language/micropython/shared/runtime/: pyexec.c stdout_helpers.c sys_stdio_mphal.c interrupt_char.c
    ../../../../components/language/micropython/shared/netutils/: netutils.c
  group micropython/extmod
    ../../../../components/language/micropython/extmod/: modframebuf.c moduasyncio.c modubinascii.c moductypes.c moduhashlib.c moduheapq.c modujson.c moduos.c modurandom.c modure.c moduselect.c moduzlib.c vfs.c vfs_reader.c uos_dupterm.c utime_mphal.c machine_signal.c virtpin.c machine_mem.c machine_spi.c machine_i2c.c modnetwork.c modusocket.c
  group micropython/drivers
    ../../../../components/language/micropython/drivers/bus/: softspi.c
  group micropython/port
    ../../../../components/language/micropython/port/: help.c mphalport.c mpmain.c mpthreadport.c
    ../../../../components/language/micropython/port/modules/: machine_hw_spi.c machine_pin.c machine_timer.c machine_uart.c modesp8266.c modmachine.c modutime.c vfs_tos.c vfs_tos_file.c
    ../micropython_basic_demo/board/: mphalboard.c
software components: CMSIS:CORE 4.3.0
