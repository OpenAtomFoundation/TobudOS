# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target GD32E230C_START (6100001::V6.10.1::.\ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_START
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: GD32E230
  c include: ..\..\..\..\platform\vendor_bsp\gd\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\..\..\..\platform\vendor_bsp\gd\GD32E23x_Firmware_Library\CMSIS;..\..\..\..\platform\vendor_bsp\gd\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;..\..\BSP\Inc;..\..\..\..\arch\arm\arm-v8m\common\include;..\..\..\..\arch\arm\arm-v8m\cortex-m23\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../../BSP/Src/: gd32e23x_it.c gd32e230c_start.c main.c systick.c
  group CMSIS
    ../../../../platform/vendor_bsp/gd/GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ../../../../platform/vendor_bsp/gd/GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../../../platform/vendor_bsp/gd/GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group tos/arch
    ../../../../arch/arm/arm-v8m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v8m/cortex-m23/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
software components: CMSIS:CORE 5.0.2
