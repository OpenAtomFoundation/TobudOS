# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L496VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TencentOS_tiny +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx,
  c include: ..\..\..\BSP\Inc;..\..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Legacy;..\..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\..\kernel\core\include;..\..\..\TOS_CONFIG;..\..\..\..\..\platform\arch\arm\cortex-m4\keil;..\..\..\..\..\kernel\pm\include;..\..\..\..\..\osal\cmsis_os;..\..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\BSP\Hardware\DHT11;..\..\..\BSP\Hardware\OLED;..\..\..\BSP\Hardware\BH1750;..\..\..\..\..\devices\m5313;..\..\..\..\..\net\at\include;..\..\..\..\..\kernel\hal\include;..\..\..\..\..\net\sal_module_wrapper;..\..\..\..\..\components\ota\download\include;..\..\..\..\..\components\ota\common\crc;..\..\..\..\..\components\ota\common\image;..\..\..\..\..\components\ota\common\flash;..\..\..\..\..\components\ota\common\partition;..\..\..\..\..\components\ota\common\env;..\..\..\..\..\components\fs\kv\include;..\..\..\..\..\components\ota\common\info;..\..\..\..\..\components\ota\recovery\include
  library: MicroLIB
  memory RVCT4: ROM 0x8007800 size 0xc8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User
    ../../../BSP/Src/: gpio.c main.c mcu_init.c stm32l4xx_hal_msp.c usart.c i2c.c stm32l4xx_it.c
  group examples
    ../../../BSP/app/: ota_download_through_http_sample.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ./: system_stm32l4xx.c
  group Hardware
    ../../../BSP/Hardware/ONCHIP_FLASH/: onchip_flash.c onchip_flash_ota.c
  group kernel
    ../../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_barrier.c tos_bitmap.c tos_rwlock.c tos_stopwatch.c
  group cpu
    ../../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_s.S port_c.c
    ../../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group cmsis
    ../../../../../osal/cmsis_os/: cmsis_os.c
  group config
    ../../../TOS_CONFIG/: tos_config.h
  group at
    ../../../../../net/at/src/: tos_at.c
  group devices
    ../../../../../devices/m5313/: m5313.c
  group sal_module_wrapper
    ../../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group hal
    ../../../../../platform/hal/st/stm32l4xx/src/: tos_hal_uart.c
  group ota_download
    ../../../../../components/ota/download/protocol/http/: ota_download_http.c
    ../../../../../components/ota/download/transport_layer/tcp/module/: hal_tcp_module.c
  group ota_common
    ../../../../../components/ota/common/flash/: ota_flash.c
    ../../../../../components/ota/common/crc/: crc8.c
    ../../../../../components/ota/common/image/: ota_image.c
    ../../../../../components/ota/common/partition/: ota_partition.c
    ../../../../../components/ota/common/env/: ota_env.c
  group kv
    ../../../../../components/fs/kv/: tos_kv.c
software components: CMSIS:CORE 4.3.0
