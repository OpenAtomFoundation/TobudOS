# Keil uVision project ALIENTEK_EXPLORER_STM32F407ZGT6.uvprojx, settings and files
target ALIENTEK_EXPLORER_STM32F407ZGT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ALIENTEK_EXPLORER_STM32F407ZGT6
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,USE_MODBUS
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F4xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\ascii;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\functions;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\include;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\rtu;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\tcp;..\..\..\..\components\connectivity\Modbus\porting\TencentOS_Tiny
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32f4xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group examples
    ../../../../examples/modbus/: modbus.c
  group modbus_src
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/ascii/: mbascii.c
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/rtu/: mbcrc.c mbrtu.c
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/: mb.c
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/tcp/: mbtcp.c
  group modbus_port
    ../../../../components/connectivity/Modbus/porting/TencentOS_Tiny/: portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 4.3.0
