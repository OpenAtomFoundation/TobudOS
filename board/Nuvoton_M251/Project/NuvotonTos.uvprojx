# Keil uVision project NuvotonTos.uvprojx, settings and files
target Target 1 (6070000::V6.7::.\ARMCLANG)
  device: M251KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: NuvotonTos
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\CMSIS;..\STARTUP;..\StdDriver\inc;..\TencentOS\arch\include;..\TencentOS\kernel\core\include;..\TencentOS\kernel\pm\include;..\TencentOS\TOS_CONFIG;..\TencentOS\arch;..\STARTUP\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../STARTUP/: system_M251.c startup_M251.s
  group StdDriver
    ../StdDriver/src/: clk.c retarget.c uart.c gpio.c sys.c
  group USER
    ./: main.c
  group Tos/arch
    ../TencentOS/arch/: port_c.c tos_cpu.c tos_fault.c port_s.S
  group Tos/kernel
    ../TencentOS/kernel/core/: tos_event.c tos_fifo.c tos_global.c tos_mmblk.c tos_mmheap.c tos_msg.c tos_mutex.c tos_pend.c tos_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../TencentOS/kernel/pm/: tos_pm.c tos_tickless.c
  group Tos/config
    ../TencentOS/TOS_CONFIG/: tos_config.h
software components: CMSIS:CORE 5.0.1
