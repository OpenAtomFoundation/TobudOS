# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,PLATFORM_HAS_STDINT,INFRA_COMPAT,INFRA_LOG,INFRA_TIMER,INFRA_REPORT,INFRA_NET,INFRA_STRING,INFRA_SHA256,MBEDTLS_CONFIG_FILE=<qcloud/tls_psk_config.h>
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\kernel\core\include;..\..\TOS-CONFIG;..\..\..\..\platform\arch\arm\cortex-m4\keil;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\BSP\Hardware\DHT11;..\..\BSP\Hardware\BH1750;..\..\BSP\Hardware\OLED;..\..\..\..\examples\helloworld;..\..\..\..\net\at\include;..\..\..\..\kernel\hal\include;..\..\..\..\net\sal_module_wrapper;..\..\..\..\examples\mqtt;..\..\..\..\devices\bc35_28_95;..\..\..\..\devices\esp8266;..\..\..\..\devices\m26;..\..\..\..\components\connectivity\iotkit-embedded-3.0.1\3rdparty\src\infra;..\..\..\..\components\connectivity\iotkit-embedded-3.0.1\3rdparty\src\dev_sign;..\..\..\..\components\connectivity\iotkit-embedded-3.0.1\3rdparty\src\mqtt;..\..\..\..\components\connectivity\iotkit-embedded-3.0.1\3rdparty\wrappers;..\..\..\..\components\security\mbedtls\3rdparty\include;..\..\..\..\components\security\mbedtls\wrapper\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32l4xx_hal_msp.c usart.c adc.c dac.c i2c.c spi.c stm32l4xx_it_module.c tim.c
  group examples
    ../../../../examples/aliyun_iotkit_csdk_mqtt/: mqtt_example.c aliyun_iotkit_csdk_mqtt.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l4xx.c
  group Hardware
    ../../BSP/Hardware/DHT11/: DHT11_BUS.c
    ../../BSP/Hardware/OLED/: oled.c
    ../../BSP/Hardware/BH1750/: BH1750.c
  group kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_stopwatch.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_s.S port_c.c
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group config
    ../../TOS-CONFIG/: tos_config.h
  group devices
    ../../../../devices/bc35_28_95/: bc35_28_95.c
    ../../../../devices/esp8266/: esp8266.c
  group hal
    ../../../../platform/hal/st/stm32l4xx/src/: tos_hal_uart.c
  group at
    ../../../../net/at/src/: tos_at.c
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group port/TencentOS_tiny
    ../../../../components/connectivity/iotkit-embedded-3.0.1/port/TencentOS_tiny/: osal_os.c osal_tcp_module.c osal_timer.c
  group iotkit/mqtt
    ../../../../components/connectivity/iotkit-embedded-3.0.1/3rdparty/src/mqtt/: mqtt_api.c
    ../../../../components/connectivity/iotkit-embedded-3.0.1/3rdparty/src/mqtt/impl/: iotx_mqtt_client.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group iotkit/infra
    ../../../../components/connectivity/iotkit-embedded-3.0.1/3rdparty/src/infra/: infra_aes.c infra_cjson.c infra_compat.c infra_defs.c infra_httpc.c infra_json_parser.c infra_log.c infra_md5.c infra_mem_stats.c infra_net.c infra_preauth.c infra_prt_nwk_payload.c infra_report.c infra_sha1.c infra_sha256.c infra_string.c infra_timer.c
  group iotkit/dev_sign
    ../../../../components/connectivity/iotkit-embedded-3.0.1/3rdparty/src/dev_sign/: dev_sign_mqtt.c
  group mbedtls
    ../../../../components/security/mbedtls/3rdparty/src/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../components/security/mbedtls/wrapper/src/: entropy_hardware_alt.c net_module_alt.c timing_alt.c
software components: CMSIS:CORE 4.3.0
