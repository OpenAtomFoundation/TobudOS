# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,NDEBUG
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\kernel\core\include;..\..\TOS-CONFIG;..\..\..\..\platform\arch\arm\cortex-m4\keil;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\BSP\Hardware\DHT11;..\..\BSP\Hardware\OLED;..\..\BSP\Hardware\BH1750;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\ascii;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\functions;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\include;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\rtu;..\..\..\..\components\connectivity\Modbus\3rdparty\freemodbus-v1.6\modbus\tcp;..\..\BSP\Hardware\Modbus_Port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32l4xx_hal_msp.c usart.c adc.c dac.c i2c.c spi.c stm32l4xx_it_modbus.c tim.c
  group examples
    ../../../../examples/modbus_te_qcloud_demo/: modbus.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l4xx.c
  group Hardware
    ../../BSP/Hardware/DHT11/: DHT11_BUS.c
    ../../BSP/Hardware/OLED/: oled.c
  group kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_s.S port_c.c
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group config
    ../../TOS-CONFIG/: tos_config.h
  group modbus_src
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/ascii/: mbascii.c
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/rtu/: mbcrc.c mbrtu.c
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/tcp/: mbtcp.c
    ../../../../components/connectivity/Modbus/3rdparty/freemodbus-v1.6/modbus/: mb.c
  group modbus_port
    ../../BSP/Hardware/Modbus_Port/: portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 4.3.0
