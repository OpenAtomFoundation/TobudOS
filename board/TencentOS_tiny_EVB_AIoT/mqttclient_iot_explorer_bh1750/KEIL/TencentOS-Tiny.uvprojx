# Keil uVision project TencentOS-Tiny.uvprojx, settings and files
target TencentOS-Tiny_debug (6140000::V6.14::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: TencentOS-Tiny.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1062DVL6A, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0,SDK_DEBUGCONSOLE_UART
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1062\CMSIS\Include;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1062\xip;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1062\drivers;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1062;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1062\utilities\debug_console_lite;..\board;..\board\xip;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1062\components\uart;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1062\components\lists;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m7\armcc;..\..\..\..\kernel\core\include;..\..\TOS-CONFIG;..\..\..\..\kernel\hal\include;..\..\..\..\net\at\include;..\..\..\..\net\sal_module_wrapper;..\..\..\..\devices\esp8266;..\..\..\..\devices\ec20_200_600;..\..\..\..\components\utils\JSON\include;..\..\..\..\components\connectivity\mqttclient\common;..\..\..\..\components\connectivity\mqttclient\mqtt;..\..\..\..\components\connectivity\mqttclient\mqttclient;..\..\..\..\components\connectivity\mqttclient\network;..\..\..\..\components\connectivity\mqttclient\platform\TencentOS-tiny;..\..\BSP\Hardware\BH1750-IIC
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_ram.scf
  link misc: --remove
  group startup
    ../../../../platform/vendor_bsp/nxp/MIMXRT1062/arm/: startup_MIMXRT1062.s
  group source
    ../: main.c
  group example
    ../: mqttclient_iot_explorer_bh1750.c
  group board
    ../board/: board.c clock_config.c dcd.c pin_mux.c mcu_init.c
  group utilities
    ../../../../platform/vendor_bsp/nxp/MIMXRT1062/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c
  group drivers
    ../../../../platform/vendor_bsp/nxp/MIMXRT1062/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexcan_edma.c fsl_flexio.c fsl_flexio_camera.c fsl_flexio_camera_edma.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_mculcd.c fsl_flexio_mculcd_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexram_allocate.c fsl_flexspi.c fsl_flexspi_edma.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ocotp.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_romapi.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_tempmon.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
  group device
    ../../../../platform/vendor_bsp/nxp/MIMXRT1062/: system_MIMXRT1062.c
  group xip
    ../../../../platform/vendor_bsp/nxp/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c
    ../board/xip/: tosevbrt1062_flexspi_nor_config.c
  group nxp/component/uart
    ../../../../platform/vendor_bsp/nxp/MIMXRT1062/components/uart/: fsl_adapter_lpuart.c
  group nxp/component/lists
    ../../../../platform/vendor_bsp/nxp/MIMXRT1062/components/lists/: fsl_component_generic_list.c
  group cpu
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m7/armcc/: port_c.c port_s.S
  group kernel
    ../../../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group config
    ../../TOS-CONFIG/: tos_config.h mqtt_config.h
  group hal/uart
    ../../../../platform/hal/nxp/mimxrt10xx/src/: tos_hal_uart.c
  group net/at
    ../../../../net/at/src/: tos_at.c
  group net/sal_module_wrapper
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group devices
    ../../../../devices/esp8266/: esp8266.c
    ../../../../devices/ec20_200_600/: ec600s.c
  group mqttclient
    ../../../../components/connectivity/mqttclient/mqttclient/: mqttclient.c
  group mqttclient/mqtt
    ../../../../components/connectivity/mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient/common
    ../../../../components/connectivity/mqttclient/common/: random.c mqtt_list.c
  group mqttclient/network
    ../../../../components/connectivity/mqttclient/network/: nettype_tcp.c nettype_tls.c network.c
  group mqttclient/platform
    ../../../../components/connectivity/mqttclient/platform/TencentOS-tiny/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group cjson
    ../../../../components/utils/JSON/src/: cJSON.c
  group hardware
    ../../BSP/Hardware/BH1750-IIC/: bh1750_i2c_drv.c
target TencentOS-Tiny flexspi_nor_release (6140000::V6.14::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1062DVL6A, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0,SDK_DEBUGCONSOLE_UART
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1062xxxxx_flexspi_nor.scf
  link misc: --remove --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
