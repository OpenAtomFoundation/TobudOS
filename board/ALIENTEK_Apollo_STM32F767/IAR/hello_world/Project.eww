<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ALIENTEK_Aploo_STM32F767.ewp</path>
  </project>
  <batchBuild />
</workspace>
