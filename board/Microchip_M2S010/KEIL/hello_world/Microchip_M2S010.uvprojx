# Keil uVision project Microchip_M2S010.uvprojx, settings and files
target Microchip_M2S010 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M2S010 Microsemi
  pack: Microsemi.M2Sxxx.1.0.64
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Microchip_M2S010 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MICROSEMI_STDIO_THRU_MMUART0
  c include: ..\..\BSP\Inc;..\..\BSP\sys_config;..\..\..\..\platform\hal\Microchip;..\..\..\..\platform\hal\Microchip\CortexM3;..\..\..\..\platform\hal\Microchip\CortexM3\Keil;..\..\..\..\platform\vendor_bsp\Microchip\SmartFusion2\Inc;..\..\..\..\platform\vendor_bsp\Microchip\SmartFusion2\CMSIS;..\..\..\..\platform\vendor_bsp\Microchip\SmartFusion2\CMSIS\startup_arm;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m3\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\platform\vendor_bsp\Microchip\SmartFusion2\CMSIS\startup_arm\smartfusion2_execute_in_place.sct
  group Application/MDK-ARM
    ./: startup_m2sxxx.s
  group Application/User
    ../../BSP/Src/: main.c mcu_init.c
    ../../BSP/Inc/: main.h mcu_init.h
    ../../BSP/sys_config/: sys_config.c sys_config_mss_clocks.h
  group Drivers/SmartFusion2_HAL_Driver
    ../../../../platform/vendor_bsp/Microchip/SmartFusion2/Src/: mss_uart.c mss_gpio.c
  group Drivers/CMSIS
    ../../../../platform/vendor_bsp/Microchip/SmartFusion2/CMSIS/: system_m2sxxx.c
    ../../../../platform/vendor_bsp/Microchip/SmartFusion2/CMSIS/startup_arm/: retarget.c low_level_init.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m3/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group tos/config
    ../../TOS_CONFIG/: tos_config.h
  group examples
    ../../../../examples/hello_world/: hello_world.c
