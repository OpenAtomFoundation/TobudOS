# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,WITH_TOS_NET_ADAPTER
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\kernel\core\include;..\..\TOS-CONFIG;..\..\..\..\platform\arch\arm\cortex-m4\keil;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\BSP\Hardware\DHT11;..\..\BSP\Hardware\OLED;..\..\BSP\Hardware\BH1750;..\..\..\..\devices\esp8266;..\..\..\..\devices\ec20_200_600;..\..\..\..\net\at\include;..\..\..\..\kernel\hal\include;..\..\..\..\net\sal_module_wrapper;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\include;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\common\cryptology\inc;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\common\mqtt_packet\inc;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\common\utils\inc;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\platform\network\inc;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\include\common;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\include\config;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\include\services\common;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\include\services\explorer;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\services\common\log_upload\inc;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\services\common\mqtt_client\inc;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\services\explorer\data_template\inc;..\..\..\..\components\connectivity\iot-hub-device-c-sdk\services\explorer\service_mqtt\inc;..\..\..\..\examples\qcloud_csdk_iot_explorer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32l4xx_hal_msp.c stm32l4xx_it_module.c usart.c adc.c dac.c i2c.c spi.c tim.c
  group examples
    ../../../../examples/qcloud_csdk_iot_explorer/: data_template_app.c data_template_config.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l4xx.c
  group Hardware
    ../../BSP/Hardware/DHT11/: DHT11_BUS.c
    ../../BSP/Hardware/OLED/: oled.c
  group kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_stopwatch.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_s.S port_c.c
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group config
    ../../TOS-CONFIG/: tos_config.h
  group at
    ../../../../net/at/src/: tos_at.c
  group devices
    ../../../../devices/esp8266/: esp8266.c
    ../../../../devices/ec20_200_600/: ec600s.c
  group sal_module_wrapper
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group hal
    ../../../../platform/hal/st/stm32l4xx/src/: tos_hal_uart.c
  group csdk/common
    ../../../../components/connectivity/iot-hub-device-c-sdk/common/cryptology/src/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/common/mqtt_packet/src/: mqtt_packet_deserialize.c mqtt_packet_serialize.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/common/utils/src/: utils_downloader.c utils_json.c utils_list.c utils_log.c
  group csdk/platform
    ../../../../components/connectivity/iot-hub-device-c-sdk/platform/network/src/: network_interface.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/platform/os/TencentOS-Tiny/: HAL_Device_tos.c HAL_File_tos.c HAL_OS_tos.c HAL_TCP_tos.c HAL_Timer_tos.c
  group csdk/service/common
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/common/cos/src/: cos_download.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/common/dynreg/src/: dynreg.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/common/http_client/src/: http_client.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/common/http_signed/src/: http_signed.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/common/log_upload/src/: log_buffer.c log_mqtt.c log_upload.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/common/mqtt_client/src/: mqtt_client.c mqtt_client_common.c mqtt_client_connect.c mqtt_client_publish.c mqtt_client_subscribe.c mqtt_client_yield.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/common/ota/src/: ota_mqtt.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/common/system/src/: system_mqtt.c
  group csdk/service/explorer
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/explorer/data_template/src/: data_template_action.c data_template_client.c data_template_event.c data_template_mqtt.c data_template_property.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/explorer/service_mqtt/src/: sevice_mqtt.c
    ../../../../components/connectivity/iot-hub-device-c-sdk/services/explorer/service_mqtt/src/file_manage/: file_manage.c
software components: CMSIS:CORE 4.3.0
