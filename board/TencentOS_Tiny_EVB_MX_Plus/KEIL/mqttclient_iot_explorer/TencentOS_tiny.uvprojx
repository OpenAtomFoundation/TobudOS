# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\kernel\core\include;..\..\TOS-CONFIG;..\..\..\..\platform\arch\arm\cortex-m4\keil;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\BSP\Hardware\DHT11;..\..\BSP\Hardware\BH1750;..\..\BSP\Hardware\OLED;..\..\..\..\examples\helloworld;..\..\..\..\net\at\include;..\..\..\..\kernel\hal\include;..\..\..\..\net\sal_module_wrapper;..\..\..\..\examples\mqtt;..\..\..\..\devices\bc35_28_95;..\..\..\..\devices\esp8266;..\..\..\..\devices\ec20_200_600;..\..\..\..\components\connectivity\mqttclient\common;..\..\..\..\components\connectivity\mqttclient\common\log;..\..\..\..\components\connectivity\mqttclient\mqtt;..\..\..\..\components\connectivity\mqttclient\mqttclient;..\..\..\..\components\connectivity\mqttclient\network;..\..\..\..\components\connectivity\mqttclient\platform\TencentOS-tiny;..\..\..\..\components\utils\JSON\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32l4xx_hal_msp.c usart.c adc.c dac.c i2c.c spi.c stm32l4xx_it_module.c tim.c
  group examples
    ./demo/: mqttclient_iot_explorer.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l4xx.c
  group Hardware
    ../../BSP/Hardware/DHT11/: DHT11_BUS.c
    ../../BSP/Hardware/OLED/: oled.c
    ../../BSP/Hardware/BH1750/: BH1750.c
  group kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_stopwatch.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_s.S port_c.c
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group config
    ../../TOS-CONFIG/: tos_config.h
  group at
    ../../../../net/at/src/: tos_at.c
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group devices
    ../../../../devices/bc35_28_95/: bc35_28_95.c
    ../../../../devices/esp8266/: esp8266.c
    ../../../../devices/ec20_200_600/: ec600s.c
  group hal
    ../../../../platform/hal/st/stm32l4xx/src/: tos_hal_uart.c
  group mqttclient
    ../../../../components/connectivity/mqttclient/mqttclient/: mqttclient.c
  group mqttclient/mqtt
    ../../../../components/connectivity/mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient/salof
    ../../../../components/connectivity/mqttclient/common/log/arch/tencentos-tiny/: arch.c
    ../../../../components/connectivity/mqttclient/common/log/: fifo.c format.c salof.c salof_config.h
  group mqttclient/common
    ../../../../components/connectivity/mqttclient/common/: random.c mqtt_list.c mqtt_log.h mqtt_error.h
  group mqttclient/network
    ../../../../components/connectivity/mqttclient/network/: network.c nettype_tls.c nettype_tcp.c
  group mqttclient/platform
    ../../../../components/connectivity/mqttclient/platform/TencentOS-tiny/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group mqttclient/config
    ../../TOS-CONFIG/: mqtt_config.h
  group cjson
    ../../../../components/utils/JSON/src/: cJSON.c
software components: CMSIS:CORE 4.3.0
