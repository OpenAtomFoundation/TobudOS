# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TencentOS_tiny
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx,USE_FULL_LL_DRIVER,REGION_CN470
  c include: ..\apps\common;..\Inc;..\TOS-CONFIG;..\..\..\components\connectivity\LoraWAN\boards_common;..\..\..\components\connectivity\LoraWAN\mac;..\..\..\components\connectivity\LoraWAN\mac\region;..\..\..\components\connectivity\LoraWAN\radio;..\..\..\components\connectivity\LoraWAN\radio\sx1276;..\..\..\components\connectivity\LoraWAN\system;..\..\..\components\connectivity\LoraWAN\peripherals\soft-se;..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\platform\vendor_bsp\st\STM32L0xx_HAL_Driver\Inc;..\..\..\platform\vendor_bsp\st\STM32L0xx_HAL_Driver\Inc\Legacy;..\..\..\kernel\core\include;..\..\..\kernel\pm\include;..\..\..\arch\arm\arm-v7m\common\include;..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\apps\classA;..\..\..\devices\at_agent\atcmd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Application/User
    ../apps/classA/: main.c LoRaApi.c at_parser.c
    ../apps/common/: NvmCtxMgmt.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../platform/vendor_bsp/st/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group board/mcu
    ../Src/: adc-board.c board.c delay-board.c eeprom-board.c gpio-board.c i2c-board.c lpm-board.c rtc-board.c spi-board.c sx1276-board.c system_stm32l0xx.c uart-board.c sysIrqHandlers.c atcmd-board.c
    ../../../components/connectivity/LoraWAN/boards_common/: utilities.c
  group lorawan/mac
    ../../../components/connectivity/LoraWAN/mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacFCntHandler.c LoRaMacParser.c LoRaMacSerializer.c
    ../../../components/connectivity/LoraWAN/peripherals/soft-se/: aes.c cmac.c soft-se.c
  group lorawan/region
    ../../../components/connectivity/LoraWAN/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group radio
    ../../../components/connectivity/LoraWAN/radio/sx1276/: sx1276.c
  group system
    ../../../components/connectivity/LoraWAN/system/: adc.c delay.c eeprom.c fifo.c gpio.c i2c.c nvmm.c systime.c timer.c uart.c
  group kernel
    ../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group cpu
    ../../../arch/arm/arm-v7m/cortex-m0+/armcc/: port_s.S port_c.c
    ../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group config
    ../TOS-CONFIG/: tos_config.h
