# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: firmware_XIP
  BeforeMake: python ..\..\..\..\platform\vendor_bsp\LN\ln882x\tools\user_cmd\before_build.py flash_partition_cfg.json flash_partition_table.h
  AfterMake: python ..\..\..\..\platform\vendor_bsp\LN\ln882x\tools\user_cmd\after_build_soc.py @L
  AfterMake: ..\..\..\..\platform\vendor_bsp\LN\ln882x\tools\bin\mkimage.exe cmd_app ..\..\..\..\platform\vendor_bsp\LN\ln882x\lib\boot_ln882x.bin @L.bin @L.asm flashimage.bin flash_partition_cfg.json ver=1.1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: LN882x,ARM_MATH_CM4
  c include: ..\..\BSP\Inc;..\..\TOS-CONFIG;..\..\..\..\kernel\pm\include;..\..\..\..\kernel\core\include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\..\osal\cmsis_os;..\..\..\..\examples\helloworld;..\hello_world;..\..\..\..\platform\vendor_bsp\LN\ln882x\include\driver_ln882x;..\..\..\..\platform\vendor_bsp\LN\ln882x\src\driver_ln882x\ll\include;..\..\..\..\components\fs\kv\include;..\..\..\..\platform\vendor_bsp\LN\ln882x\include;..\..\..\..\platform\vendor_bsp\LN\ln882x\include\cpu\ARM_CM4F\ln88xx;..\..\..\..\platform\vendor_bsp\LN\ln882x\include\kernel;..\..\..\..\platform\vendor_bsp\LN\ln882x\include\cpu\ARM_CM4F\CMSIS_5.3.0;..\..\..\..\platform\vendor_bsp\LN\ln882x\include\wifi_manager;..\..\..\..\platform\vendor_bsp\LN\ln882x\include\net;..\..\..\..\platform\vendor_bsp\LN\ln882x\src\net\lwip-2.0.3\src\include;..\..\..\..\platform\vendor_bsp\LN\ln882x\src\net\lwip-2.0.3\src\port;..\..\..\..\platform\vendor_bsp\LN\ln882x\src\net\lwip-2.0.3\src\port\arch;..\..\..\..\components\connectivity\mqttclient\common;..\..\..\..\components\connectivity\mqttclient\mqtt;..\..\..\..\components\connectivity\mqttclient\mqttclient;..\..\..\..\components\connectivity\mqttclient\network;..\..\..\..\components\connectivity\mqttclient\platform\TencentOS-tiny;..\..\..\..\platform\vendor_bsp\LN\ln882x\src\wifi\wifi_port;..\..\..\..\platform\vendor_bsp\LN\ln882x\src\fs\kv\kv_port;..\..\..\..\platform\vendor_bsp\LN\ln882x\src\fs\kv\kv;..\..\..\..\platform\vendor_bsp\LN\ln882x\src\fs\nvds;..\..\..\..\platform\vendor_bsp\LN\ln882x\src\fs\partition_mgr;..\mqtt_client
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ln882x.sct
  link misc: --no_autoat --keep=*.o(no_init_data)
  group Application/MDK-ARM
    ../../../../platform/vendor_bsp/LN/ln882x/src/cpu/ARM_CM4F/ln88xx/: startup_ln882x.S system_ln88xx.c
  group Application/User
    ../../BSP/Src/: main.c
  group examples
    ../../BSP/Src/: mqttclient_examples.c mqtt_task.c
  group Drivers/HAL
    ../../../../platform/vendor_bsp/LN/ln882x/src/driver_ln882x/hal/: hal_common.c hal_syscon.c cache.c hal_dma.c qspi.c hal_uart.c flash.c hal_trng.c hal_timer.c hal_sleep.c hal_efuse.c hal_adc.c hal_interrupt.c
  group kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group config
    ../../TOS-CONFIG/: tos_config.h proj_config.h
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group bsp
    ../../BSP/Src/: mcu_init.c serial_hw.c drv_adc_measure.c
  group serial
    ../../../../platform/vendor_bsp/LN/ln882x/src/serial/: serial.c
  group console
    ../../../../platform/vendor_bsp/LN/ln882x/src/console/: console.c
  group at_cmd
    ../../../../platform/vendor_bsp/LN/ln882x/src/atcmd/: at_cmd_basic.c at_cmd_wifi.c at_list.c at_parser.c at_string.c at_task.c
  group utils
    ../../../../platform/vendor_bsp/LN/ln882x/src/utils/debug/: log.c art_assert.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/utils/: art_string.c art_time.c crc16.c crc32.c gbk_to_unicode.c md5.c wrap_stdio.c eeprom.c system_parameter.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/utils/fifo/: fifobuf.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/utils/debug/CmBacktrace/: cm_backtrace.c
  group os_adapter_inc
    ../../../../platform/vendor_bsp/LN/ln882x/include/kernel/osal/: osal.h
  group os_adapter_src
    ../../../../platform/vendor_bsp/LN/ln882x/src/kernel/TencentOS_Adapter/: TencentOS_common.c TencentOS_debug.c TencentOS_mutex.c TencentOS_queue.c TencentOS_semaphore.c TencentOS_thread.c TencentOS_timer.c
  group lib
    ../../../../platform/vendor_bsp/LN/ln882x/lib/: arm_cortexM4lf_math.lib wifi_mac.lib soc_driver.lib
  group wifi_manager
    ../../../../platform/vendor_bsp/LN/ln882x/src/wifi/wifi_manager/: wifi_manager.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/wifi/wifi_port/: wifi_port.c
  group lwip_core
    ../../../../platform/vendor_bsp/LN/ln882x/src/net/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/net/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip_api
    ../../../../platform/vendor_bsp/LN/ln882x/src/net/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_netif
    ../../../../platform/vendor_bsp/LN/ln882x/src/net/lwip-2.0.3/src/netif/: ethernet.c ethernetif.c
  group lwip_port
    ../../../../platform/vendor_bsp/LN/ln882x/src/net/lwip-2.0.3/src/port/arch/: lwip_hooks.c sys_arch.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/net/lwip-2.0.3/src/port/: lwipopts.h
  group net
    ../../../../platform/vendor_bsp/LN/ln882x/src/net/dhcpd/: dhcp_packet.c dhcpd.c ip_allocator.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/net/iperf/: iperf.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/net/ping/: ping.c
  group fs
    ../../../../platform/vendor_bsp/LN/ln882x/src/fs/kv/kv/: ln_kv.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/fs/kv/kv_port/: ln_kv_port.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/fs/partition_mgr/: flash_partition_mgr.c
    ../../../../platform/vendor_bsp/LN/ln882x/src/fs/nvds/: nvds.c
  group mqttclient
    ../../../../components/connectivity/mqttclient/mqttclient/: mqttclient.c
    ../../TOS-CONFIG/: mqtt_config.h
  group mqttclient/mqtt
    ../../../../components/connectivity/mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient/commom
    ../../../../components/connectivity/mqttclient/common/: random.c mqtt_list.c mqtt_log.h mqtt_error.h
  group mqttclient/network
    ../../../../components/connectivity/mqttclient/network/: network.c nettype_tls.c nettype_tcp.c
  group mqttclient/platform
    ../../../../components/connectivity/mqttclient/platform/TencentOS-tiny/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
software components: CMSIS:CORE 5.1.2
