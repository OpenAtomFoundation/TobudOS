# Keil uVision project hello_world.uvprojx, settings and files
target hello_world debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.12.0.0
  cpu: IRAM(0x20208000,0x8000) IRAM2(0x20000000,0x8000) XRAM(0x00000000,0x8000) XRAM2(0x20200000,0x8000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MIMXRT1011DAE5A, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: ..\..\bsp\Inc;..\..\bsp\xip;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\CMSIS\Include;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\components\uart;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\components\serial_manager;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\utilities\debug_console;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\utilities\str;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\xip;..\..\..\..\platform\vendor_bsp\nxp\MIMXRT1011\drivers;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m7\armcc;..\..\..\..\osal\cmsis_os;..\..\..\..\kernel\core\include;..\..\tos_config;..\..\..\..\kernel\pm\include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x8000
  memory RVCT7: RAM 0x20200000 size 0x8000
  memory RVCT9: RAM 0x20208000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\MIMXRT1011xxxxx_ram.scf
  link misc: --remove
  group user
    ../../bsp/Src/: board.c clock_config.c hello_world.c pin_mux.c
    ../../bsp/Inc/: board.h clock_config.h pin_mux.h
  group component/uart
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group device
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h system_MIMXRT1011.c system_MIMXRT1011.h
  group drivers
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group startup
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/arm/: startup_MIMXRT1011.s
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/common/include/: tos_cpu.h tos_cpu_def.h tos_cpu_types.h
    ../../../../arch/arm/arm-v7m/cortex-m7/armcc/: port.h port_c.c port_config.h port_s.S
  group tos/cmsis_os
    ../../../../osal/cmsis_os/: cmsis_os.c cmsis_os.h
  group tos/kernel
    ../../../../kernel/core/include/: tos_binary_heap.h tos_char_fifo.h tos_compiler.h tos_completion.h tos_config_check.h tos_config_default.h tos_countdownlatch.h tos_err.h tos_event.h tos_global.h tos_k.h tos_klib.h tos_ktypes.h tos_list.h tos_mail_queue.h tos_message_queue.h tos_mmblk.h tos_mmheap.h tos_mutex.h tos_pend.h tos_priority_mail_queue.h tos_priority_message_queue.h tos_priority_queue.h tos_ring_queue.h tos_robin.h tos_sched.h tos_sem.h tos_slist.h tos_sys.h tos_task.h tos_tick.h tos_time.h tos_timer.h
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group xip
    ../../bsp/xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group utilities
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../platform/vendor_bsp/nxp/MIMXRT1011/utilities/: fsl_assert.c
target hello_world flexspi_nor_debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.12.0.0
  cpu: as above
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1011DAE5A, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x8000
  memory RVCT7: RAM 0x20200000 size 0x8000
  memory RVCT9: RAM 0x20208000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: --remove --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target hello_world release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.12.0.0
  cpu: as above
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MIMXRT1011DAE5A, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x8000
  memory RVCT7: RAM 0x20200000 size 0x8000
  memory RVCT9: RAM 0x20208000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\MIMXRT1011xxxxx_ram.scf
  link misc: --remove
target hello_world flexspi_nor_release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1011DAE5A NXP
  pack: NXP.MIMXRT1011_DFP.12.0.0
  cpu: as above
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, NDEBUG, CPU_MIMXRT1011DAE5A, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc --diag_suppress=1296,186
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x0 size 0x8000
  memory RVCT7: RAM 0x20200000 size 0x8000
  memory RVCT9: RAM 0x20208000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\MIMXRT1011xxxxx_flexspi_nor.scf
  link misc: as above
