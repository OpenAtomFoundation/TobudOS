# IAR project GD32E507Z_EVAL.ewp, settings and files
configuration GD32E50x (ARM, debug)
  General.OGChipSelectEditMenu: GD32E507xE GD GD32E507xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X_CL; GD32E50X
  ICCARM.CCIncludePath2: ..\..\BSP\Inc; ..\..\..\..\platform\vendor_bsp\gd\GD32E50x_Firmware_Library\CMSIS; ..\..\..\..\platform\vendor_bsp\gd\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include; ..\..\..\..\platform\vendor_bsp\gd\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include; ..\..\..\..\arch\arm\arm-v8m\common\include; ..\..\..\..\arch\arm\arm-v8m\cortex-m33\iccarm; ..\..\..\..\osal\cmsis_os; ..\..\..\..\kernel\core\include; ..\..\..\..\kernel\pm\include; ..\..\TOS_CONFIG
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32E507Z_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../BSP/Src/: gd32e507z_eval.c gd32e507z_lcd_eval.c gd32e50x_it.c main.c systick.c
  group CMSIS
    ../../../../platform/vendor_bsp/gd/GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/IAR/: startup_gd32e50x_cl.s
    ../../../../platform/vendor_bsp/gd/GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../../../../platform/vendor_bsp/gd/GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group tos/arch
    ../../../../arch/arm/arm-v8m/cortex-m33/iccarm/: port_c.c port_s.S
    ../../../../arch/arm/arm-v8m/common/: tos_cpu.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group tos/config
    ../../TOS_CONFIG/: tos_config.h
  group tos/kernel
    ../../../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
