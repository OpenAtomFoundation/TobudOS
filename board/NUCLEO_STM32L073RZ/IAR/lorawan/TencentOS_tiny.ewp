# IAR project TencentOS_tiny.ewp, settings and files
configuration TencentOS_tiny (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx; USE_HAL_DRIVER; STM32L073xx
  ICCARM.CCIncludePath2: ../../BSP/Inc; ../../../../platform/vendor_bsp/st/STM32L0xx_HAL_Driver/Inc; ../../../../platform/vendor_bsp/st/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../platform/vendor_bsp/st/CMSIS/Device/ST/STM32L0xx/Include; ../../../../platform/vendor_bsp/st/CMSIS/Include; ../../../../arch/arm/arm-v7m/common/include; ../../../../arch/arm/arm-v7m/cortex-m0+/armcc; ../../../../kernel/core/include; ../../../../kernel/pm/include; ../../../../kernel/hal/include; ../../../../osal/cmsis_os; ../../TOS_CONFIG; ../../../../devices/rhf76_lora; ../../../../net/at/include; ../../../../net/lora_module_wrapper; ../../BSP/HardWare/HTS221; ../../../../examples/LoRaWAN; $PROJ_DIR$; ..\..\BSP\HardWare\LPS22HB; ..\..\BSP\HardWare\Common; ..\..\BSP\HardWare\LIS3MDL; ..\..\BSP\HardWare\LSM6DS3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TencentOS_tiny.srec
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../../BSP/Src/: gpio.c i2c.c main.c mcu_init.c stm32l0xx_hal_msp.c stm32l0xx_it_lorawan.c usart.c
  group Application/User/BSP
    ../../BSP/HardWare/Common/: bsp.c
  group Application/User/BSP/HTS221
    ../../BSP/HardWare/HTS221/: HTS221.c
  group Application/User/BSP/LIS3MDL
    ../../BSP/HardWare/LIS3MDL/: LIS3MDL.c
  group Application/User/BSP/LPS22HB
    ../../BSP/HardWare/LPS22HB/: LPS22HB.c
  group Application/User/BSP/LSM6DS3
    ../../BSP/HardWare/LSM6DS3/: LSM6DS3.c
  group at
    ../../../../net/lora_module_wrapper/: lora_module_wrapper.c
    ../../../../net/at/src/: tos_at.c
  group devices
    ../../../../devices/rhf76_lora/: RHF76.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ex2.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/STM32L0xx_HAL_Driver/Drivers/CMSIS
    ../../BSP/Src/: system_stm32l0xx.c
  group examples
    ../../BSP/Src/: lora_demo.c
  group hal
    ../../../../platform/hal/st/stm32l0xx/src/: tos_hal_uart.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/cortex-m0+/iccarm/: port_c.c port_s.S
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group tos/cmsis_os
    ../../../../osal/cmsis_os/: cmsis_os.c
  group tos/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
