# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TencentOS_tiny
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51,NIMBLE_CFG_CONTROLLER=1,
  c misc: --reduce_paths --gnu
  c include: ..\..\BSP\Inc;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS_CONFIG;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\porting\nimble\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\porting\npl\TencentOS tiny\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\ext\tinycrypt\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\controller\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\drivers\nrf51\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\transport\ram\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\drivers\Nordic Soc\nrfx;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\drivers\Nordic Soc\nrfx\templates\nRF51;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\drivers\Nordic Soc\nrfx\templates;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\services\lls\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\services\ans\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\services\bas\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\services\bleuart\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\services\gap\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\services\ias\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\services\lls\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\services\tps\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\services\gatt\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\store\ram\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\nimble\host\util\include;..\..\..\..\components\connectivity\Bluetooth 5.0\3rdparty\NimBLE\porting\npl\TencentOS tiny\include;..\..\..\..\platform\vendor_bsp\nordic\nRF5_SDK_15.3.0_59ac345\modules\nrfx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./: arm_startup_nrf51.s
  group Drivers
    ../../BSP/Src/: nrf_delay.c rtc.c system_nrf51.c simple_uart.c mcu_init.c
  group tos/arch
    ../../../../arch/arm/arm-v6m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v6m/cortex-m0/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_event.c tos_fifo.c tos_global.c tos_mmblk.c tos_mmheap.c tos_msg.c tos_mutex.c tos_pend.c tos_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group example
    ../../../../examples/blehr/: gatt_svr.c main.c
  group TOS-CONFIG
    ../../TOS_CONFIG/: tos_config.h
  group NimBLE/host/src
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/src/: ble_att.c ble_att_clt.c ble_att_cmd.c ble_att_svr.c ble_eddystone.c ble_gap.c ble_gattc.c ble_gatts.c ble_gatts_lcl.c ble_hs.c ble_hs_adv.c ble_hs_atomic.c ble_hs_cfg.c ble_hs_conn.c ble_hs_dbg.c ble_hs_flow.c ble_hs_hci.c ble_hs_hci_cmd.c ble_hs_hci_evt.c ble_hs_hci_util.c ble_hs_id.c ble_hs_log.c ble_hs_mbuf.c ble_hs_misc.c ble_hs_mqueue.c ble_hs_periodic_sync.c ble_hs_pvcy.c ble_hs_shutdown.c ble_hs_startup.c ble_hs_stop.c ble_ibeacon.c ble_l2cap.c ble_l2cap_coc.c ble_l2cap_sig.c ble_l2cap_sig_cmd.c ble_monitor.c ble_sm.c ble_sm_alg.c ble_sm_cmd.c ble_sm_lgcy.c ble_sm_sc.c ble_store.c ble_store_util.c ble_uuid.c
  group NimBLE/controller
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/controller/src/: ble_ll.c ble_ll_adv.c ble_ll_conn.c ble_ll_conn_hci.c ble_ll_ctrl.c ble_ll_dtm.c ble_ll_hci.c ble_ll_hci_ev.c ble_ll_rand.c ble_ll_resolv.c ble_ll_scan.c ble_ll_sched.c ble_ll_supp_cmd.c ble_ll_sync.c ble_ll_trace.c ble_ll_utils.c ble_ll_whitelist.c ble_ll_xcvr.c
  group NimBLE/port
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/porting/nimble/src/: endian.c hal_timer.c mem.c nimble_port.c os_cputime.c os_cputime_pwr2.c os_mbuf.c os_mempool.c os_msys_init.c
  group NimBLE/tinycrypt
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/ext/tinycrypt/src/: aes_decrypt.c aes_encrypt.c cmac_mode.c ecc.c ecc_dh.c utils.c
  group NimBLE/transport/ram
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/transport/ram/src/: ble_hci_ram.c
  group NimBLE/src
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/src/: ble_util.c
  group NimBLE/drivers/nrf51
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/drivers/nrf51/src/: ble_hw.c ble_phy.c
  group NimBLE/TencentOS_tiny
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/porting/npl/TencentOS tiny/src/: nimble_port_tencentos_tiny.c npl_os_tencenos_tiny.c nrf5x_isr.c tencent_os_tiny_libc.c
  group NimBLE/host/services/ans
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/services/ans/src/: ble_svc_ans.c
  group NimBLE/host/services/bas
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/services/bas/src/: ble_svc_bas.c
  group NimBLE/host/services/bleuart
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/services/bleuart/src/: bleuart.c
  group NimBLE/host/services/gap
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/services/gap/src/: ble_svc_gap.c
  group NimBLE/host/services/gatt
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/services/gatt/src/: ble_svc_gatt.c
  group NimBLE/host/services/ias
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/services/ias/src/: ble_svc_ias.c
  group NimBLE/host/services/lls
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/services/lls/src/: ble_svc_lls.c
  group NimBLE/host/services/tps
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/services/tps/src/: ble_svc_tps.c
  group NimBLE/host/store/ram
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/store/ram/src/: ble_store_ram.c
  group NimBLE/host/util
    ../../../../components/connectivity/Bluetooth 5.0/3rdparty/NimBLE/nimble/host/util/src/: addr.c
software components: CMSIS:CORE 5.1.1
