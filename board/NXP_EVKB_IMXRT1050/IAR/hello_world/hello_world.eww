<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>hello_world</project>
        <configuration>ram_0x1400_debug</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>ram_0x1400_release</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>sdram_txt_debug</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>sdram_txt_release</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>release</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>sdram_debug</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>sdram_release</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>hello_world</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>ram_0x1400_debug</name>
      <member>
        <project>hello_world</project>
        <configuration>ram_0x1400_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>ram_0x1400_release</name>
      <member>
        <project>hello_world</project>
        <configuration>ram_0x1400_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_txt_debug</name>
      <member>
        <project>hello_world</project>
        <configuration>sdram_txt_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_txt_release</name>
      <member>
        <project>hello_world</project>
        <configuration>sdram_txt_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>hello_world</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_debug</name>
      <member>
        <project>hello_world</project>
        <configuration>flexspi_nor_sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_sdram_release</name>
      <member>
        <project>hello_world</project>
        <configuration>flexspi_nor_sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>hello_world</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_debug</name>
      <member>
        <project>hello_world</project>
        <configuration>sdram_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdram_release</name>
      <member>
        <project>hello_world</project>
        <configuration>sdram_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>hello_world</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>hello_world</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/hello_world.ewp</path>
  </project>
</workspace>
