# Keil uVision project GoKit3_STM32F103C8T6.uvprojx, settings and files
target GoKit3_STM32F103C8T6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GoKit3_STM32F103C8T6
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F1xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m3\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\TOS-CONFIG;..\..\BSP\HardWare\OLED;..\..\..\..\components\connectivity\mqttclient\common;..\..\..\..\components\connectivity\mqttclient\common\log;..\..\..\..\components\connectivity\mqttclient\mqtt;..\..\..\..\components\connectivity\mqttclient\mqttclient;..\..\..\..\components\connectivity\mqttclient\network;..\..\..\..\components\connectivity\mqttclient\platform\TencentOS-tiny;..\..\..\..\net\sal_module_wrapper;..\..\..\..\devices\esp8266;..\..\..\..\kernel\hal\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../../BSP/Src/: stm32f1xx_hal_msp.c
    ./: stm32f1xx_it.c
  group Application/Bsp
    ../../BSP/Src/: bsp_dwt.c bsp_init.c bsp_led.c bsp_motor.c bsp_usart.c
  group examples
    ../../../../examples/mqttclient/: gokit3_mqttclient.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32f1xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m3/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group tos/at
    ../../../../net/at/src/: tos_at.c tos_at_utils.c
  group tos/sal
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group tos/hal
    ../../BSP/Src/: tos_hal_uart.c
  group tos/devices
    ../../../../devices/esp8266/: esp8266.c
  group mqttclient
    ../../../../components/connectivity/mqttclient/mqttclient/: mqttclient.c
  group mqttclient/mqtt
    ../../../../components/connectivity/mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient/salof
    ../../../../components/connectivity/mqttclient/common/log/: fifo.c format.c salof.c salof_config.h
    ../../../../components/connectivity/mqttclient/common/log/arch/tencentos-tiny/: arch.c
  group mqttclient/common
    ../../../../components/connectivity/mqttclient/common/: list.c random.c log.h error.h
  group mqttclient/network
    ../../../../components/connectivity/mqttclient/network/: network.c
  group mqttclient/platform
    ../../../../components/connectivity/mqttclient/platform/TencentOS-tiny/: platform_memory.c platform_mutex.c platform_net_socket.c platform_nettype_tcp.c platform_nettype_tls.c platform_thread.c platform_timer.c
  group mqttclient/config
    ../../TOS-CONFIG/: mqtt_config.h
software components: CMSIS:CORE 4.3.0
