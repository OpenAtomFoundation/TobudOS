# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431CBTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,WITH_TOS_NET_ADAPTER,USE_ESP8266,MBEDTLS_CONFIG_FILE=<iothub_tls_config.h>,MQTT_COMM_ENABLED
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\..\..\net\lora_module_wrapper;..\..\..\..\net\sal_module_wrapper;..\..\..\..\net\at\include;..\..\..\..\devices\esp8266;..\..\..\..\devices\rhf76_lora;..\..\TOS-CONFIG;..\..\BSP\Hardware\BH1750;..\..\BSP\Hardware\DHT11;..\..\BSP\Hardware\OLED;..\..\..\..\examples\TencentCloud_SDK;..\..\..\..\components\connectivity\TencentCloud_SDK\ports\TencentOS_tiny\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\mqtt\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\shadow\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\coap\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\device\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\system\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\sdk-impl;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\sdk-impl\exports;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\utils\digest;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\utils\farra;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\utils\lite;..\..\..\..\components\security\mbedtls\3rdparty\include;..\..\..\..\components\security\mbedtls\wrapper\include;..\..\..\..\kernel\hal\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../../BSP/Src/: gpio.c i2c.c main.c mcu_init.c stm32l4xx_hal_msp.c stm32l4xx_it_mqtt.c usart.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l4xx.c
  group hardware
    ../../BSP/Hardware/BH1750/: BH1750.c
    ../../BSP/Hardware/DHT11/: DHT11_BUS.c
    ../../BSP/Hardware/OLED/: oled.c
  group kernel
    ../../../../kernel/core/: tos_event.c tos_fifo.c tos_global.c tos_mmblk.c tos_mmheap.c tos_msg.c tos_mutex.c tos_pend.c tos_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_s.S port_c.c
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group module_wrapper
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
    ../../../../net/lora_module_wrapper/: lora_module_wrapper.c
  group devices
    ../../../../devices/esp8266/: esp8266.c
    ../../../../devices/rhf76_lora/: RHF76.c
  group config
    ../../TOS-CONFIG/: tos_config.h
  group examples
    ../../../../examples/tencent_cloud_sdk_mqtt/: mqtt_sample.c tencent_cloud_sdk_mqtt.c
  group tencent_cloud_sdk/port
    ../../../../components/connectivity/TencentCloud_SDK/ports/TencentOS_tiny/: tos_hal_os.c tos_hal_tcp.c tos_hal_timer.c
    ../../../../components/connectivity/TencentCloud_SDK/ports/ssl/: HAL_TLS_mbedtls.c
  group tencent_cloud_sdk/mqtt
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/mqtt/src/: mqtt_client.c mqtt_client_common.c mqtt_client_connect.c mqtt_client_net.c mqtt_client_publish.c mqtt_client_subscribe.c mqtt_client_unsubscribe.c mqtt_client_yield.c
  group tencent_cloud_sdk/sdk-impl
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/sdk-impl/: qcloud_iot_sdk_impl.c
  group tencent_cloud_sdk/device
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/device/src/: device.c ca.c
  group tencent_cloud_sdk/utils/digest
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
  group tencent_cloud_sdk/utils/frara
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/utils/farra/: utils_list.c utils_net.c utils_timer.c
  group tencent_cloud_sdk/system
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/system/src/: log_mqtt.c log_upload.c system_mqtt.c
  group mbedtls_wrapper
    ../../../../components/security/mbedtls/wrapper/src/: entropy_hardware_alt.c net_sockets_alt.c timing_alt.c
  group mbedtls
    ../../../../components/security/mbedtls/3rdparty/src/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group hal
    ../../../../platform/hal/st/stm32l4xx/src/: tos_hal_uart.c
  group at-framwork
    ../../../../net/at/src/: tos_at.c tos_at_utils.c
software components: CMSIS:CORE 4.3.0
