# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TencentOS_tiny +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx,NUCLEO_STM32L496ZG
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\osal\cmsis_os;..\..\..\..\examples\hello_world;..\..\TOS_CONFIG;..\..\..\..\net\at\include;..\..\..\..\kernel\hal\include;..\..\BSP\Hardware\Inc;..\..\..\..\components\ai\nnom\inc;..\..\..\..\components\ai\nnom\inc\layers;..\..\..\..\components\ai\nnom\port;..\..\..\..\examples\nnom_mnist\data
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User
    ../../BSP/Src/: main.c gpio.c stm32l4xx_hal_msp.c stm32l4xx_it.c sys.c usart.c mcu_init.c dcmi.c dma.c i2c.c spi.c tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32l4xx.c
  group tos/arch
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../../kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis_os
    ../../../../osal/cmsis_os/: cmsis_os.c
  group hal
    ../../BSP/Hardware/Src/: delay.c lcd_2inch4.c lcd_config.c ov2640.c sccb.c
  group examples
    ../../../../examples/nnom_mnist/: nnom_mnsit_example.c
  group nnom
    ../../../../components/ai/nnom/src/backends/: nnom_local.c nnom_local_q15.c
    ../../../../components/ai/nnom/src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
    ../../../../components/ai/nnom/src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
software components: CMSIS:CORE 5.4.0
