<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TencentOS_tiny.ewp</path>
  </project>
  <batchBuild />
</workspace>
