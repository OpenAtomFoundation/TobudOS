<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F103_SIM800A.ewp</path>
  </project>
  <batchBuild />
</workspace>
