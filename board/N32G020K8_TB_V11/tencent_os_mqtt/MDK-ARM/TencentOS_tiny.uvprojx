# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: mqtt
  AfterMake: fromelf.exe --bin .\Objects\mqtt.axf --output=.\bin\mqtt.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: LOG_ENABLE LOG_POSITION WITH_TOS_NET_ADAPTER
  c include: ../../../../platform/vendor_bsp/nationz/n32g020xx/cmsis/cm0/core/include;../../../../platform/vendor_bsp/nationz/n32g020xx/cmsis/cm0/device/n32g020xx;../../../../platform/vendor_bsp/nationz/n32g020xx/n32g020xx_stdperiph_driver/include;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\kernel\hal\include;../TOS-CONFIG;../Inc;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\..\..\..\devices\bc26;..\..\..\..\net\sal_module_wrapper;..\..\..\..\osal\cmsis_os;..\..\..\..\net\at\include;..\..\..\..\components\connectivity\Eclipse-Paho-MQTT\3rdparty\include;..\..\..\..\components\connectivity\Eclipse-Paho-MQTT\wrapper\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\_sct\n32g020k8.sct
  group Application/MDK-ARM
    ./: startup_n32g020xx.s
  group Application/User
    ../src/: n32g020xx_it.c main.c
  group n32g020xx_stdperiph_driver
    ../../../../platform/vendor_bsp/nationz/n32g020xx/n32g020xx_stdperiph_driver/source/: n32g020xx_adc.c n32g020xx_cgu.c n32g020xx_common.c n32g020xx_crc.c n32g020xx_dac.c n32g020xx_dma.c n32g020xx_flash.c n32g020xx_i2c.c n32g020xx_icache.c n32g020xx_iom.c n32g020xx_log.c n32g020xx_pmu.c n32g020xx_pwm.c n32g020xx_rcvcnt.c n32g020xx_rtc.c n32g020xx_scc.c n32g020xx_scd.c n32g020xx_spi.c n32g020xx_timer.c n32g020xx_uart.c n32g020xx_watchdog.c
  group Drivers/CMSIS
    ../src/: system_n32g020xx.c
  group kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_stopwatch.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m0+/armcc/: port_c.c port_s.S
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group tos_config
    ../TOS-CONFIG/: tos_config.h
  group sal_module_wrapper
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group devices
    ../../../../devices/bc26/: bc26.c
  group hal
    ../../../../platform/hal/nationz/N32G020XX/src/: tos_hal_uart.c
  group at-framwork
    ../../../../net/at/src/: tos_at.c
  group mqtt
    ../../../../components/connectivity/Eclipse-Paho-MQTT/wrapper/src/: mqtt_wrapper.c transport_wrapper.c
    ../../../../components/connectivity/Eclipse-Paho-MQTT/3rdparty/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
