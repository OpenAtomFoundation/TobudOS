# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: tencent_cloud_sdk
  AfterMake: fromelf.exe --bin .\Objects\tencent_cloud_sdk.axf --output=.\bin\tencent_cloud_sdk.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: LOG_ENABLE LOG_POSITION WITH_TOS_NET_ADAPTER,MBEDTLS_CONFIG_FILE=<iothub_tls_config.h>,MQTT_COMM_ENABLED
  c include: ../../../../platform/vendor_bsp/nationz/n32g020xx/cmsis/cm0/core/include;../../../../platform/vendor_bsp/nationz/n32g020xx/cmsis/cm0/device/n32g020xx;../../../../platform/vendor_bsp/nationz/n32g020xx/n32g020xx_stdperiph_driver/include;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\kernel\hal\include;../TOS-CONFIG;../Inc;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m0+\armcc;..\..\..\..\devices\bc26;..\..\..\..\net\sal_module_wrapper;..\..\..\..\osal\cmsis_os;..\..\..\..\net\at\include;..\..\..\..\components\connectivity\Eclipse-Paho-MQTT\3rdparty\include;..\..\..\..\components\connectivity\Eclipse-Paho-MQTT\wrapper\include;..\..\..\..\components\connectivity\TencentCloud_SDK\ports\TencentOS_tiny\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\mqtt\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\shadow\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\coap\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\device\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\system\include;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\sdk-impl;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\sdk-impl\exports;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\utils\digest;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\utils\farra;..\..\..\..\components\connectivity\TencentCloud_SDK\qcloud-iot-sdk-embedded-c\src\utils\lite;..\..\..\..\components\security\mbedtls\3rdparty\include;..\..\..\..\components\security\mbedtls\wrapper\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\_sct\n32g020k8.sct
  group Application/MDK-ARM
    ./: startup_n32g020xx.s
  group Application/User
    ../src/: n32g020xx_it.c main.c
  group examples
    ../../../../components/connectivity/TencentCloud_SDK/samples/iot_hub_platform/: mqtt_sample.c
  group n32g020xx_stdperiph_driver
    ../../../../platform/vendor_bsp/nationz/n32g020xx/n32g020xx_stdperiph_driver/source/: n32g020xx_adc.c n32g020xx_cgu.c n32g020xx_common.c n32g020xx_crc.c n32g020xx_dac.c n32g020xx_dma.c n32g020xx_flash.c n32g020xx_i2c.c n32g020xx_icache.c n32g020xx_iom.c n32g020xx_log.c n32g020xx_pmu.c n32g020xx_pwm.c n32g020xx_rcvcnt.c n32g020xx_rtc.c n32g020xx_scc.c n32g020xx_scd.c n32g020xx_spi.c n32g020xx_timer.c n32g020xx_uart.c n32g020xx_watchdog.c
  group Drivers/CMSIS
    ../src/: system_n32g020xx.c
  group kernel
    ../../../../kernel/core/: tos_event.c tos_fifo.c tos_global.c tos_mmblk.c tos_mmheap.c tos_msg.c tos_mutex.c tos_pend.c tos_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m0+/armcc/: port_c.c port_s.S
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group tos_config
    ../TOS-CONFIG/: tos_config.h
  group sal_module_wrapper
    ../../../../net/sal_module_wrapper/: sal_module_wrapper.c
  group devices
    ../../../../devices/bc26/: bc26.c
  group hal
    ../../../../platform/hal/nationz/N32G020XX/src/: tos_hal_uart.c
  group at-framwork
    ../../../../net/at/src/: tos_at.c tos_at_utils.c
  group tencent_cloud_sdk/port
    ../../../../components/connectivity/TencentCloud_SDK/ports/TencentOS_tiny/: tos_hal_os.c tos_hal_tcp.c tos_hal_timer.c
    ../../../../components/connectivity/TencentCloud_SDK/ports/ssl/: HAL_TLS_mbedtls.c
  group tencent_cloud_sdk/mqtt
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/mqtt/src/: mqtt_client.c mqtt_client_common.c mqtt_client_connect.c mqtt_client_net.c mqtt_client_publish.c mqtt_client_subscribe.c mqtt_client_unsubscribe.c mqtt_client_yield.c
  group tencent_cloud_sdk/sdk-impl
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/sdk-impl/: qcloud_iot_sdk_impl.c
  group tencent_cloud_sdk/device
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/device/src/: ca.c device.c
  group tencent_cloud_sdk/utils/digest
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
  group tencent_cloud_sdk/utils/frara
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/utils/farra/: utils_list.c utils_net.c utils_timer.c
  group tencent_cloud_sdk/system
    ../../../../components/connectivity/TencentCloud_SDK/qcloud-iot-sdk-embedded-c/src/system/src/: log_mqtt.c log_upload.c system_mqtt.c
  group mbedtls_wrapper
    ../../../../components/security/mbedtls/wrapper/src/: entropy_hardware_alt.c net_sockets_alt.c timing_alt.c
  group mbedtls
    ../../../../components/security/mbedtls/3rdparty/src/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
