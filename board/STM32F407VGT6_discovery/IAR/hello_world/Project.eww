<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F407VGT6_discovery.ewp</path>
  </project>
  <batchBuild />
</workspace>
