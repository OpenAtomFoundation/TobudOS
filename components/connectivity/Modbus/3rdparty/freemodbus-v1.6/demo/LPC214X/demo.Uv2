### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Demo), 0x0005 // Tools: ''

Group (Demo)
Group (FreeModbus)

File 1,1,<.\demo.c><demo.c> 0x0 
File 1,1,<.\port\porttimer.c><porttimer.c> 0x0 
File 1,1,<.\port\port.c><port.c> 0x0 
File 1,1,<.\port\portevent.c><portevent.c> 0x0 
File 1,1,<.\port\portserial.c><portserial.c> 0x0 
File 1,2,<.\Startup.s><Startup.s> 0x0 
File 2,1,<..\..\modbus\mb.c><mb.c> 0x0 
File 2,1,<..\..\modbus\functions\mbutils.c><mbutils.c> 0x0 
File 2,1,<..\..\modbus\functions\mbfunccoils.c><mbfunccoils.c> 0x0 
File 2,1,<..\..\modbus\functions\mbfuncdiag.c><mbfuncdiag.c> 0x0 
File 2,1,<..\..\modbus\functions\mbfuncdisc.c><mbfuncdisc.c> 0x0 
File 2,1,<..\..\modbus\functions\mbfuncholding.c><mbfuncholding.c> 0x0 
File 2,1,<..\..\modbus\functions\mbfuncinput.c><mbfuncinput.c> 0x0 
File 2,1,<..\..\modbus\functions\mbfuncother.c><mbfuncother.c> 0x0 
File 2,1,<..\..\modbus\rtu\mbrtu.c><mbrtu.c> 0x0 
File 2,1,<..\..\modbus\rtu\mbcrc.c><mbcrc.c> 0x0 
File 2,1,<..\..\modbus\ascii\mbascii.c><mbascii.c> 0x0 


Options 1,0,0  // Target 'Demo'
 Device (LPC2148)
 Vendor (Philips)
 Cpu (IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI))
 FlashUt (LPC210x_ISP.EXE ("#H" ^X $D COM1: 38400 1))
 StupF ("STARTUP\Philips\Startup.s" ("Philips LPC2100 Startup Code"))
 FlashDR (UL2ARM(-U268761108 -O7 -C0 -FO15 -FD40000000 -FC800 -FN1 -FF0LPC_IAP2_512 -FS00 -FL07D000))
 DevID ()
 Rgf (LPC214X.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿPhilips\)
 OrgReg (ÿPhilips\)
 TgStat=16
 OutDir (.\build\obj\)
 OutName (demo)
 GenApp=1
 GenLib=0
 GenHex=0
 Debug=1
 Browse=1
 LstDir (.\build\lst\)
 HexSel=0
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 KACPU (ARM7TDMI)
 TKAFL { 0,27,183,0,0,15,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 KIROM { 1,0,0,0,0,0,0,8,0 }
 KIRAM { 0,0,0,0,64,0,128,0,0 }
 KXRAM { 0,0,0,0,0,0,0,0,0 }
 KAOCM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 KCAFLG { 197,152,20,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 KCAMSC ()
 KCADEF ()
 KCAUDF ()
 KCAINC (..\..\modbus\include;..\..\modbus\rtu;..\..\modbus\ascii;.\port)
 KAAFLG { 20,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 KAAMSC ()
 KAASET ()
 KAARST ()
 KAAINC ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 KLAFLG { 44,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 KLAMSC ()
 KLADWN ()
 KLACFI ()
 KLAASN ()
 KLARES ()
 KLACCL ()
 KLAUCL ()
 KLACSC ()
 KLAUCS ()
  OPTDL (SARM.DLL)(-cLPC2100)(DARMP.DLL)(-pLPC2148)(SARM.DLL)()(TARMP.DLL)(-pLPC2148)
  OPTDBG 48125,0,()()()()()()()()()() (BIN\UL2ARM.DLL)()()()
 FLASH1 { 2,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\UL2ARM.DLL)
 FLASH3 ("LPC210x_ISP.EXE" ("#H" ^X $D COM1: 38400 1))
 FLASH4 ()
EndOpt

