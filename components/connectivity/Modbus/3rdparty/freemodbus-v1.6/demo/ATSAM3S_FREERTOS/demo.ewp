# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: at91sam3s4; flash
  ICCARM.CCIncludePath2: board; libraries; libraries\drivers; port; freertos\include; freertos\; freertos\portable\IAR\ARM_CM3; ..\..\modbus\include; ..\..\modbus\rtu; ..\..\modbus\ascii
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: freertos\
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: board\at91sam3s4\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: demo.c
  group board
    board/: board_cstartup_iar.c board_lowlevel.c board_memories.c exceptions.c
  group drivers
    libraries/drivers/pio/: pio.c
    libraries/drivers/pmc/: pmc.c
    libraries/drivers/tc/: tc.c
    libraries/drivers/usart/: usart.c
    libraries/drivers/wdt/: wdt.c
  group freertos
    freertos/: croutine.c FreeRTOSConfig.h list.c queue.c tasks.c
    freertos/portable/MemMang/: heap_2.c
    freertos/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group modbus
    ../../modbus/: mb.c
    ../../modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ../../modbus/ascii/: mbascii.c mbascii.h
    ../../modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group port
    port/: port.h portevent.c portother.c portserial.c porttimer.c
