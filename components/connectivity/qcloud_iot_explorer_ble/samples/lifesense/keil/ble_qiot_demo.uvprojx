# Keil uVision project ble_qiot_demo.uvprojx, settings and files
target ble_freertos_watch (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ble_freertos_watch +hex
  AfterMake: fromelf --bin --output bin\ble_freertos_watch.bin bin\ble_freertos_watch.axf
  AfterMake: fromelf -cedrst --output bin\ble_freertos_watch.txt bin\ble_freertos_watch.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_DEBUG_PRINTF AM_PART_APOLLO3 SEC_ECC_CFG=SEC_ECC_CFG_UECC WSF_TRACE_ENABLED AM_CUSTOM_BDADDR AM_FREERTOS AM_PACKAGE_BGA keil
  c include: ../../../../../third_party/exactle/ble-profiles/sources/apps/app;../../../../../third_party/exactle/ble-profiles/sources/profiles/anpc;../../../../../third_party/exactle/ble-host/sources/stack/cfg;../../../../../third_party/exactle/ble-profiles/sources/profiles/uribeacon;../../../../../third_party/exactle/ble-host/sources/hci/ambiq;../../../../../third_party/exactle/ble-host/sources/sec/common;../../../../../CMSIS/AmbiqMicro/Include;../../../../../third_party/exactle/ble-profiles/sources/profiles;../../../../../utils;../../../bsp;../../../../../third_party/exactle/ble-profiles/sources/profiles/paspc;../../../../../third_party/exactle/ble-profiles/sources/services;../../../../../third_party/exactle/wsf/include;../../../../../third_party/exactle/ble-host/sources/stack/dm;../../../../../third_party/uecc;../src;../../../../../third_party/exactle/ble-host/sources/stack/hci;../../../../../third_party/exactle/ble-host/sources/hci/ambiq/apollo3;../../../../../third_party/exactle/ble-profiles/sources/profiles/wdxs;../../../../../third_party/exactle/ble-profiles/sources/profiles/include;../../../../../third_party/exactle/ble-profiles/sources/profiles/hid;../../../../../third_party/exactle/ble-profiles/sources/profiles/gatt;../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../third_party/exactle/ble-host/sources/hci/include;../../../../../third_party/exactle/ble-profiles/sources/profiles/hrpc;../../../../../third_party/exactle/ble-profiles/sources/apps;../../../../../third_party/FreeRTOSv10.1.1/Source/include;../../../../../mcu/apollo3;../../../../../third_party/exactle/ble-profiles/sources/profiles/dis;../../../../../third_party/exactle/ble-host/include;../../../../../third_party/exactle/ble-profiles/sources/profiles/bas;../../../../../third_party/exactle/wsf/sources/port/freertos;../../../../../CMSIS/ARM/Include;../../../../../third_party/exactle/ble-host/sources/stack/l2c;../../../../../third_party/exactle/ble-host/sources/stack/smp;../../../../../third_party/exactle/ble-host/sources/stack/att;../../../../../third_party/exactle/wsf/sources;../../../../../third_party/exactle/ble-profiles/include/app;../../../../../third_party/exactle/ble-profiles/sources/profiles/gap;../../../../../third_party/exactle/ble-profiles/sources/profiles/tipc;../../../../../third_party/exactle/wsf/sources/util;../../../../..;../../../../../devices;..\rtt;..\data_template;..\qcloud_iot_explorer_ble\inc;..\qcloud_iot_explorer_ble\src\internal_inc
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\ble_freertos_watch.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group exactle_anpc
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/anpc/: anpc_main.c
  group exactle_cfg
    ../../../../../third_party/exactle/ble-host/sources/stack/cfg/: cfg_stack.c
  group exactle_hrpc
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/hrpc/: hrpc_main.c
  group exactle_ambiq
    ../../../../../third_party/exactle/ble-host/sources/hci/ambiq/: hci_cmd.c hci_cmd_ae.c hci_cmd_cte.c hci_cmd_past.c hci_cmd_phy.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c hci_vs_ae.c
  group exactle_common
    ../../../../../third_party/exactle/ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_debug.c sec_ecc_hci.c sec_main.c
  group exactle_dis
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/dis/: dis_main.c
  group exactle_bas
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/bas/: bas_main.c
  group exactle_freertos
    ../../../../../third_party/exactle/wsf/sources/port/freertos/: wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
  group exactle_l2c
    ../../../../../third_party/exactle/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
  group exactle_paspc
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/paspc/: paspc_main.c
  group exactle_dm
    ../../../../../third_party/exactle/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
  group exactle_smp
    ../../../../../third_party/exactle/ble-host/sources/stack/smp/: smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c
  group uecc_uecc
    ../../../../../third_party/uecc/: uECC.c uECC_ll.c
  group src
    ../src/: radio_task.c rtos.c ble_qiot_demo.c watch_main.c apollo3_service.c
  group exactle_fmpl
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/fmpl/: fmpl_main.c
  group exactle_att
    ../../../../../third_party/exactle/ble-host/sources/stack/att/: attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c att_main.c att_uuid.c
  group exactle_hci
    ../../../../../third_party/exactle/ble-host/sources/stack/hci/: hci_main.c
  group exactle_hidapp
    ../../../../../third_party/exactle/ble-profiles/sources/apps/hidapp/: hidapp_main.c
  group exactle_common
    ../../../../../third_party/exactle/ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
  group exactle_apollo3
    ../../../../../third_party/exactle/ble-host/sources/hci/ambiq/apollo3/: hci_drv_apollo3.c
  group exactle_uecc
    ../../../../../third_party/exactle/ble-host/sources/sec/uecc/: sec_ecc.c
  group exactle_hid
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/hid/: hid_main.c
  group exactle_gatt
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/gatt/: gatt_main.c
  group FreeRTOSv10.1.1_AMapollo2
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
  group exactle_gap
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/gap/: gap_main.c
  group exactle_tipc
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/tipc/: tipc_main.c
  group exactle_util
    ../../../../../third_party/exactle/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
  group exactle_app
    ../../../../../third_party/exactle/ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
  group utils
    ../../../../../utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group FreeRTOSv10.1.1_Source
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group devices
    ../../../../../devices/: am_devices_button.c am_devices_led.c
  group exactle_services
    ../../../../../third_party/exactle/ble-profiles/sources/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
  group rtt
    ../rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group qcloud_iot_explorer_ble
    ../qcloud_iot_explorer_ble/src/core/: ble_qiot_llsync_data.c ble_qiot_llsync_device.c ble_qiot_llsync_event.c ble_qiot_service.c
    ../qcloud_iot_explorer_ble/src/utils/: ble_qiot_utils_base64.c ble_qiot_utils_hmac.c ble_qiot_utils_md5.c ble_qiot_utils_sha1.c ble_qiot_utils_log.c
    ../data_template/: ble_qiot_template.c
