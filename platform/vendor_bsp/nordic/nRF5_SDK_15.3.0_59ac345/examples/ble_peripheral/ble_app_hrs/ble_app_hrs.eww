<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\ble_app_hrs_pca10056_s140.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s312\iar\ble_app_hrs_pca10040_s312.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10059\s140\iar\ble_app_hrs_pca10059_s140.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s340\iar\ble_app_hrs_pca10056_s340.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s332\iar\ble_app_hrs_pca10040_s332.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\ble_app_hrs_pca10040_s132.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040e\s112\iar\ble_app_hrs_pca10040e_s112.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056e\s112\iar\ble_app_hrs_pca10056e_s112.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_spi\iar\ble_app_hrs_pca10040_s132_spi.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\ser_s140_hci\iar\ble_app_hrs_pca10056_s140_hci.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s112_hci\iar\ble_app_hrs_pca10040_s112_hci.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\ser_s140_spi\iar\ble_app_hrs_pca10056_s140_spi.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_hci\iar\ble_app_hrs_pca10040_s132_hci.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\ser_s140_uart\iar\ble_app_hrs_pca10056_s140_uart.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_uart\iar\ble_app_hrs_pca10040_s132_uart.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\ser_s140_spi_5W\iar\ble_app_hrs_pca10056_s140_spi_5W.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_spi_5W\iar\ble_app_hrs_pca10040_s132_spi_5W.ewp</path>
  </project>  <batchBuild/>
</workspace>