<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\ble_app_hrs_freertos_pca10040_s132.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\ble_app_hrs_freertos_pca10056_s140.ewp</path>
  </project>  <batchBuild/>
</workspace>