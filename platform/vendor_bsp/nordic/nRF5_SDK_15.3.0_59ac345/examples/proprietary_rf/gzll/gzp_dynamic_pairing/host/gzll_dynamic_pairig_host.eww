<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\gzll_dynamic_pairig_host_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\blank\iar\gzll_dynamic_pairig_host_pca10040.ewp</path>
  </project>  <batchBuild/>
</workspace>