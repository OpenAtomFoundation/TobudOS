<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\ble_nfc_pairing_reference_c_pca10040_s132.ewp</path>
  </project>  <batchBuild/>
</workspace>