<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\ser_s140_spi\iar\ble_connectivity_s140_spi_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_hci\iar\ble_connectivity_s132_hci_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\ser_s140_hci\iar\ble_connectivity_s140_hci_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_spi\iar\ble_connectivity_s132_spi_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\ser_s140_uart\iar\ble_connectivity_s140_uart_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056e\ser_s112_hci\iar\ble_connectivity_s112_hci_pca10056e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040e\ser_s112_hci\iar\ble_connectivity_s112_hci_pca10040e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040e\ser_s112_spi\iar\ble_connectivity_s112_spi_pca10040e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056e\ser_s112_spi\iar\ble_connectivity_s112_spi_pca10056e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_uart\iar\ble_connectivity_s132_uart_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040e\ser_s112_uart\iar\ble_connectivity_s112_uart_pca10040e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056e\ser_s112_uart\iar\ble_connectivity_s112_uart_pca10056e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\ser_s140_spi_5W\iar\ble_connectivity_s140_spi_5W_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s132_spi_5W\iar\ble_connectivity_s132_spi_5W_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\ser_s140_usb_hci\iar\ble_connectivity_s140_usb_hci_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040e\ser_s112_spi_5W\iar\ble_connectivity_s112_spi_5W_pca10040e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056e\ser_s112_spi_5W\iar\ble_connectivity_s112_spi_5W_pca10056e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10059\ser_s140_usb_hci\iar\ble_connectivity_s140_usb_hci_pca10059.ewp</path>
  </project>  <batchBuild/>
</workspace>