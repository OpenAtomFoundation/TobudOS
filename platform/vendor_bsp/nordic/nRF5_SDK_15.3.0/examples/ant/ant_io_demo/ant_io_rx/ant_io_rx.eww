<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s212\iar\ant_io_rx_pca10040_s212.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\d52_starterkit\s212\iar\ant_io_rx_d52_starterkit_s212.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\ser_s212_uart\iar\ant_io_rx_pca10040_s212_uart.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\d52_starterkit\ser_s212_uart\iar\ant_io_rx_d52_starterkit_s212_uart.ewp</path>
  </project>  <batchBuild/>
</workspace>