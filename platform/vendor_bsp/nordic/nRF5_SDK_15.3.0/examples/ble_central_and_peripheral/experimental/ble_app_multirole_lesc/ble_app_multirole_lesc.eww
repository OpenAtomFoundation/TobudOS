<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\ble_app_multirole_lesc_s132_pca10040.ewp</path>
  </project>  <batchBuild/>
</workspace>