<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\cli_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\blank\iar\cli_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10059\mbr\iar\cli_pca10059_mbr.ewp</path>
  </project>  <batchBuild/>
</workspace>