<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\usbd_ble_uart_pca10056_s140.ewp</path>
  </project>  <batchBuild/>
</workspace>