<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10040\s132\iar\flash_fstorage_s132_pca10040.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\flash_fstorage_s140_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\flash_fstorage_blank_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\blank\iar\flash_fstorage_blank_pca10040.ewp</path>
  </project>  <batchBuild/>
</workspace>