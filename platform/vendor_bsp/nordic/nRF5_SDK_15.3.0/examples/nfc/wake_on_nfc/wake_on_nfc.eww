<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\wake_on_nfc_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10040\blank\iar\wake_on_nfc_pca10040.ewp</path>
  </project>  <batchBuild/>
</workspace>